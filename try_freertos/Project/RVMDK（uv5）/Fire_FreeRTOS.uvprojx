# Keil uVision project Fire_FreeRTOS.uvprojx, settings and files
target Fire_FreeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Fire_FreeRTOS +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,OS_SUPPORT
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM4F;..\..\User\key;..\..\User\led;..\..\User\Bsp\usart1;..\..\User\Bsp\DMA;..\..\User\Bsp\SPI_FLASH;..\..\User\Bsp\IIC_EEPROM;..\..\User\Bsp\ADC_TEMP;..\..\User\Bsp\RTC;..\..\User\Bsp\PWR_STOP;..\..\User\STemWin;..\..\User\STemWin\Config;..\..\User\STemWin\OS;..\..\User\STemWin\inc;..\..\User\STemWin\Lib;..\..\User\Bsp\LTDC;..\..\User\Bsp\LCD;..\..\User\Bsp\TOUCH;..\..\User\Bsp\STemWIN_TASK;..\..\User\FATFS;..\..\User\Bsp\FATFS_TASK;..\..\User\FATFS\option;..\..\User\Bsp\SDIO;..\..\User\Bsp\STemWIN_TOOL;..\..\User\Bsp\STemWIN_ICON;..\..\User\STemWin\png;..\..\User\TRACEALYZER\TraceRecorder\include;..\..\User\TRACEALYZER\TraceRecorder;..\..\User\TRACEALYZER\TraceRecorder\config;..\..\User\STemWin\APP_Lib;..\..\User\Bsp\MALLOC;..\..\User\Bsp\STemWIN_ICON\Manage_sel;..\..\User\Bsp\STemWIN_ICON\Menu_;..\..\User\Bsp\STemWIN_ICON\System_set;..\..\User\Bsp\STemWIN_ICON\Monitor;..\..\User\Bsp\STemWIN_ICON\Disposition;..\..\User\Bsp\STemWIN_ICON
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c FreeRTOSConfig.h
    ../../User/led/: bsp_led.c
    ../../User/key/: bsp_key.c
    ../../User/Bsp/usart1/: bsp_usart.c bsp_usart.h
    ../../User/Bsp/IIC_EEPROM/: bsp_i2c.c bsp_i2c.h bsp_i2c_ee_hard.c bsp_i2c_ee_hard.h
    ../../User/Bsp/SPI_FLASH/: bsp_spi_flash.c bsp_spi_flash.h
    ../../User/Bsp/ADC_TEMP/: bsp_adc_temp.c bsp_adc_temp.h
    ../../User/Bsp/RTC/: bsp_rtc.c bsp_rtc.h bsp_rtc_tim.c bsp_rtc_tim.h
    ../../User/Bsp/PWR_STOP/: bsp_pwr_stop.c bsp_pwr_stop.h
    ../../User/Bsp/LCD/: bsp_lcd.c bsp_lcd.h
    ../../User/Bsp/TOUCH/: bsp_touch_lcd.c bsp_touch_lcd.h bsp_touch_spi.c bsp_touch_spi.h bsp_touch.c bsp_touch.h bsp_touch_myiic.c bsp_touch_myiic.h bsp_touch_at24cxx.c bsp_touch_at24cxx.h
    ../../User/Bsp/SDIO/: bsp_sdio_sd.c bsp_sdio_sd.h
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group DOC
    ../../: 必读说明.txt
  group STemWIN
    ../../User/STemWin/Config/: GUIConf.c GUIDRV_wf.c GUIConf.h
    ../../User/STemWin/OS/: GUI_X_FreeRTOS.c
    ../../User/STemWin/Lib/: STemWin_CM4_OS_wc16_ot.a
    ../../User/Bsp/TOUCH/: GUITP.c GUITP.h font.h song.h
    ../../User/STemWin/inc/: Global.h
    ../../User/STemWin/: YaHei24B.h YaHei18B.h YaHei11.h
  group STemWin/Task
    ../../User/Bsp/STemWIN_TASK/: bsp_keyboard.c bsp_keyboard.h Win_DispositionDLG.c Win_DispositionDLG.h Dispositon_ChildDLG.c Dispositon_ChildDLG.h Connect_WinDLG.c Connect_WinDLG.h Win_LoginDLG.c Win_LoginDLG.h Win_Manage_SelectDLG.c Win_Manage_SelectDLG.h Win_MenuDLG.c Win_MenuDLG.h Win_System_SetDLG.c Win_System_SetDLG.h Win_MonitorDLG.c Win_MonitorDLG.h Menu_Child_WindowDLG.c Menu_Child_WindowDLG.h Log_TimeSel_WinDLG.c Log_TimeSel_WinDLG.h Log_WinDLG.c Log_WinDLG.h Canlender_WindowDLG.c Canlender_WindowDLG.h Calibrate_WindowDLG.c Calibrate_WindowDLG.h
  group FATFS
    ../../User/FATFS/option/: syscall.c cc936.c
    ../../User/FATFS/: diskio.c diskio.h ff.c ff.h
  group FATFS/Task
    ../../User/Bsp/FATFS_TASK/: FatFs_test.c FatFs_test.h
  group STemWin/Tool
    ../../User/Bsp/STemWIN_TOOL/: bsp_tool.c bsp_tool.h
  group STemWIN/Icon
    ../../User/Bsp/STemWIN_ICON/: Analyse_Icon.c Logo_Icon.c code.c num.c Logo_mini_Icon.c Save_Icon.c Search_Icon.c Calender_Icon.c
    ../../User/Bsp/STemWIN_ICON/System_set/: Link_Icon.c Menu_Icon.c Return_Icon.c System_Calender_Icon.c System_Calibrate_Icon.c System_Repositon_Icon.c
    ../../User/Bsp/STemWIN_ICON/Menu_/: Desprition_Icon.c Menu_Info_Icon.c Monitor_Icon.c Quit_Icon.c Setting_Icon.c Statistics_Icon.c User_Icon.c Warning_Icon.c Working_Time_Icon.c Close_Icon.c
    ../../User/Bsp/STemWIN_ICON/Manage_sel/: Add_Icon.c System_Setting_Icon.c User_Setting_Icon.c Log_Setting_Icon.c
    ../../User/Bsp/STemWIN_ICON/Monitor/: Connect_Icon.c
    ../../User/Bsp/STemWIN_ICON/Disposition/: Deg_Max_Icon.c Deg_Min_Icon.c Deg_Target_Icon.c Del_Icon.c Nm_Max_Icon.c Nm_Min_Icon.c Nm_Target_Icon.c Task_Next_Icon.c Task_Prev_Icon.c
